// Each glyph below was authored directly as a 5(w)x7(h) pixel grid (see the
// ASCII-art comment above each entry, '#'=lit/'.'=blank, top row first) and
// then hand-encoded into column-major bytes -- not transcribed from memory
// of some external font table, which would have been unverifiable without
// a way to render it. test/test_font5x7.c decodes every glyph below back
// into the same ASCII-art form and prints it, so the intended shape above
// each entry can be checked by eye against the test's stdout on the
// "linux" host target before this ever reaches the real display.
#include "font5x7.h"
#include <stddef.h>

typedef struct {
    char c;
    uint8_t cols[FONT5X7_WIDTH];
} glyph_entry_t;

static const uint8_t BLANK_GLYPH[FONT5X7_WIDTH] = { 0x00, 0x00, 0x00, 0x00, 0x00 };

static const glyph_entry_t GLYPHS[] = {
    // .....
    // .....
    // .....
    // .....
    // .....
    // .....
    // .....
    { ' ', { 0x00, 0x00, 0x00, 0x00, 0x00 } },

    // .###.
    // #...#
    // #...#
    // #...#
    // #...#
    // #...#
    // .###.
    { '0', { 0x3E, 0x41, 0x41, 0x41, 0x3E } },

    // ..#..
    // .##..
    // ..#..
    // ..#..
    // ..#..
    // ..#..
    // .###.
    { '1', { 0x00, 0x42, 0x7F, 0x40, 0x00 } },

    // .###.
    // #...#
    // ....#
    // ...#.
    // ..#..
    // .#...
    // #####
    { '2', { 0x42, 0x61, 0x51, 0x49, 0x46 } },

    // .###.
    // #...#
    // ....#
    // ..##.
    // ....#
    // #...#
    // .###.
    { '3', { 0x22, 0x41, 0x49, 0x49, 0x36 } },

    // ...#.
    // ..##.
    // .#.#.
    // #..#.
    // #####
    // ...#.
    // ...#.
    { '4', { 0x18, 0x14, 0x12, 0x7F, 0x10 } },

    // #####
    // #....
    // ####.
    // ....#
    // ....#
    // #...#
    // .###.
    { '5', { 0x27, 0x45, 0x45, 0x45, 0x39 } },

    // ..##.
    // .#...
    // #....
    // ####.
    // #...#
    // #...#
    // .###.
    { '6', { 0x3C, 0x4A, 0x49, 0x49, 0x30 } },

    // #####
    // ....#
    // ...#.
    // ..#..
    // .#...
    // .#...
    // .#...
    { '7', { 0x01, 0x71, 0x09, 0x05, 0x03 } },

    // .###.
    // #...#
    // #...#
    // .###.
    // #...#
    // #...#
    // .###.
    { '8', { 0x36, 0x49, 0x49, 0x49, 0x36 } },

    // .###.
    // #...#
    // #...#
    // .####
    // ....#
    // ...#.
    // .##..
    { '9', { 0x06, 0x49, 0x49, 0x29, 0x1E } },

    // .....
    // .....
    // .###.
    // ....#
    // .####
    // #...#
    // .####
    { 'a', { 0x20, 0x54, 0x54, 0x54, 0x78 } },

    // #....
    // #....
    // ####.
    // #...#
    // #...#
    // #...#
    // ####.
    { 'b', { 0x7F, 0x44, 0x44, 0x44, 0x38 } },

    // .....
    // .....
    // .###.
    // #...#
    // #####
    // #....
    // .###.
    { 'e', { 0x38, 0x54, 0x54, 0x54, 0x18 } },

    // .....
    // .####
    // #...#
    // #...#
    // .####
    // ....#
    // .###.
    { 'g', { 0x0C, 0x52, 0x52, 0x52, 0x3E } },

    // ..#..
    // .....
    // .##..
    // ..#..
    // ..#..
    // ..#..
    // .###.
    { 'i', { 0x00, 0x44, 0x7D, 0x40, 0x00 } },

    // .##..
    // ..#..
    // ..#..
    // ..#..
    // ..#..
    // ..#..
    // .###.
    { 'l', { 0x00, 0x41, 0x7F, 0x40, 0x00 } },

    // .....
    // .....
    // #.##.
    // ##..#
    // #...#
    // #...#
    // #...#
    { 'n', { 0x7C, 0x08, 0x04, 0x04, 0x78 } },

    // .....
    // .....
    // .###.
    // #...#
    // #...#
    // #...#
    // .###.
    { 'o', { 0x38, 0x44, 0x44, 0x44, 0x38 } },

    // .....
    // .....
    // #.##.
    // ##..#
    // #....
    // #....
    // #....
    { 'r', { 0x7C, 0x08, 0x04, 0x04, 0x08 } },

    // .....
    // .....
    // .####
    // #....
    // .###.
    // ....#
    // ####.
    { 's', { 0x48, 0x54, 0x54, 0x54, 0x24 } },

    // .....
    // .....
    // #...#
    // #...#
    // #...#
    // #...#
    // .####
    { 'u', { 0x3C, 0x40, 0x40, 0x40, 0x7C } },

    // .....
    // .....
    // #...#
    // #...#
    // #...#
    // .#.#.
    // ..#..
    { 'v', { 0x1C, 0x20, 0x40, 0x20, 0x1C } },

    // #....
    // #....
    // #.##.
    // ##..#
    // #...#
    // #...#
    // #...#
    { 'h', { 0x7F, 0x08, 0x04, 0x04, 0x78 } },

    // .....
    // .....
    // #...#
    // #...#
    // .####
    // ....#
    // .###.
    { 'y', { 0x0C, 0x50, 0x50, 0x50, 0x3C } },

    // #....
    // #....
    // #..#.
    // #.#..
    // ##...
    // #.#..
    // #..#.
    { 'k', { 0x7F, 0x10, 0x28, 0x44, 0x00 } },

    // ....#
    // ....#
    // .##.#
    // #..##
    // #...#
    // #...#
    // .####
    { 'd', { 0x38, 0x44, 0x44, 0x48, 0x7F } },

    // .....
    // .....
    // #...#
    // #.#.#
    // #.#.#
    // #.#.#
    // .#.#.
    { 'w', { 0x3C, 0x40, 0x38, 0x40, 0x3C } },

    // c,f,j,m,p,q,t,x,z,-,_,/ added for the KEY2 network-info screen:
    // its labels ("rete", "ping", "ms", "10") need t/p/m//, and it shows
    // the connected network's SSID verbatim, which can be any letter --
    // so this now completes a-z rather than adding just what one fixed
    // string needs (see font5x7_glyph()'s uppercase folding for A-Z).

    // .....
    // .....
    // .###.
    // #....
    // #....
    // #...#
    // .###.
    { 'c', { 0x38, 0x44, 0x44, 0x44, 0x20 } },

    // ..##.
    // .#..#
    // .#...
    // ###..
    // .#...
    // .#...
    // .#...
    { 'f', { 0x08, 0x7E, 0x09, 0x01, 0x02 } },

    // ...#.
    // .....
    // ..##.
    // ...#.
    // ...#.
    // #..#.
    // .##..
    { 'j', { 0x20, 0x40, 0x44, 0x3D, 0x00 } },

    // .....
    // .....
    // ##.#.
    // #.#.#
    // #.#.#
    // #...#
    // #...#
    { 'm', { 0x7C, 0x04, 0x18, 0x04, 0x78 } },

    // .....
    // .....
    // ####.
    // #...#
    // ####.
    // #....
    // #....
    { 'p', { 0x7C, 0x14, 0x14, 0x14, 0x08 } },

    // .....
    // .....
    // .####
    // #...#
    // .####
    // ....#
    // ....#
    { 'q', { 0x08, 0x14, 0x14, 0x14, 0x7C } },

    // .#...
    // .#...
    // ####.
    // .#...
    // .#...
    // .#..#
    // ..##.
    { 't', { 0x04, 0x3F, 0x44, 0x44, 0x20 } },

    // .....
    // .....
    // #...#
    // .#.#.
    // ..#..
    // .#.#.
    // #...#
    { 'x', { 0x44, 0x28, 0x10, 0x28, 0x44 } },

    // .....
    // .....
    // #####
    // ...#.
    // ..#..
    // .#...
    // #####
    { 'z', { 0x44, 0x64, 0x54, 0x4C, 0x44 } },

    // .....
    // .....
    // .....
    // #####
    // .....
    // .....
    // .....
    { '-', { 0x08, 0x08, 0x08, 0x08, 0x08 } },

    // .....
    // .....
    // .....
    // .....
    // .....
    // .....
    // #####
    { '_', { 0x40, 0x40, 0x40, 0x40, 0x40 } },

    // ....#
    // ....#
    // ...#.
    // ..#..
    // .#...
    // #....
    // #....
    { '/', { 0x60, 0x10, 0x08, 0x04, 0x03 } },

    // .....
    // .....
    // .....
    // .....
    // .....
    // .##..
    // .##..
    { '.', { 0x00, 0x60, 0x60, 0x00, 0x00 } },

    // .....
    // .##..
    // .##..
    // .....
    // .##..
    // .##..
    // .....
    { ':', { 0x00, 0x36, 0x36, 0x00, 0x00 } },
};

#define GLYPH_COUNT (sizeof(GLYPHS) / sizeof(GLYPHS[0]))

const uint8_t *font5x7_glyph(char c)
{
    // No separate uppercase glyphs -- A-Z render as their lowercase form
    // (arbitrary SSIDs on the network-info screen are the only mixed-case
    // text this display ever shows, and legibility matters more there
    // than case fidelity).
    if (c >= 'A' && c <= 'Z') {
        c = (char)(c - 'A' + 'a');
    }
    for (size_t i = 0; i < GLYPH_COUNT; i++) {
        if (GLYPHS[i].c == c) {
            return GLYPHS[i].cols;
        }
    }
    return BLANK_GLYPH;
}
